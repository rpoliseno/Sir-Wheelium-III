<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Sir-Wheelium-III.ewp</path>
  </project>
  <batchBuild/>
</workspace>


