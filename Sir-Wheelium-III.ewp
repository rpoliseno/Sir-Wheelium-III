# IAR project Sir-Wheelium-III.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; STM8L15x-16x-05x-AL31-L_StdPeriph_Lib; STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Utilities; STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Utilities\STM8_EVAL; STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Utilities\STM8_EVAL\Common; STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Utilities\Misc; STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Libraries\STM8L15x_StdPeriph_Driver\inc; STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Libraries\STM8L15x_StdPeriph_Driver\src; C:\Users\dthrasher\Documents\Sir-Wheelium-III\STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Utilities\STM8_EVAL\STM8L1526_EVAL
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Sir-Wheelium-III.srec
  ILINK.IlinkOutputFile: Sir-Wheelium-III.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: Bluetooth.c Bluetooth.h main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h UART.c UART.h
    STM8L15x-16x-05x-AL31-L_StdPeriph_Lib/Utilities/STM8_EVAL/Common/: stm8_eval_lcd.c stm8_eval_lcd.h
    STM8L15x-16x-05x-AL31-L_StdPeriph_Lib/Utilities/STM8_EVAL/STM8L1526_EVAL/: stm8l1526_eval.c stm8l1526_eval.h
    STM8L15x-16x-05x-AL31-L_StdPeriph_Lib/Libraries/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_comp.h stm8l15x_exti.h stm8l15x_gpio.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim2.h
    STM8L15x-16x-05x-AL31-L_StdPeriph_Lib/Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim2.c
    STM8L15x-16x-05x-AL31-L_StdPeriph_Lib/Utilities/Misc/: timing_delay.c timing_delay.h
